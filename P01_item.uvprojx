# Keil uVision project P01_item.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: P36_FSMC_register +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=2
  c include: .\Start;.\User;.\Common;.\Driver;.\Inf;.\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group User
    ./User/: main.c Delay.c
  group App
    ./App/: App_Display.c App_Water_level.c App_TDS.c
  group Inf
    ./Inf/: Driver_LCD.c Inf_water_level.c Inf_W25Q32.c Inf_ADS1115.c
  group Driver
    ./Driver/: Driver_usart1.c Driver_FSMC.c Driver_LCD_FSMC.c Driver_GPIO.c Driver_SPI.c Driver_IIC.c
  group Common
    ./Common/: Debug .c
